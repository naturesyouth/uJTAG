# Repository naturesyouth/uJTAG

## KiCad design uJTAG.kicad_pcb

Parts:
C1, C4: 4u7; C_0805_HandSoldering
C2, C3, C5, C6, C7, C8, C9, C10, C14, C16: 100n; C_0805_HandSoldering
C11, C12: 22p; C_0805_HandSoldering
C13, C17: 1u; C_0805_HandSoldering
C15: 10n; C_0805_HandSoldering
D1: LED; LED_1206
D2: BAT60J; SOD-323
FB1, FB2: FILTER; Choke_SMD_1206_Handsoldering
J1: USB_3; USB_Mini-B
LOGO1: OPEN_HARDWARE_2
P1: CONN_6; Pin_Header_Straight_2x05
R1: 12k; R_0805_HandSoldering
R2: 270; R_0805_HandSoldering
U1: FT232H; LQFP-48_7x7mm_Pitch0.5mm
U2: LD3985M; SOT-23-5
X1: CRYSTAL; Crystal_SMD_0603_4Pads

Connections:
3V3: C3.2, C5.2, C7.2, C8.1, C9.1, C16.1, C17.1, D1.1 (A), D2.1 (A), FB1.1, FB2.1, U1.12 (VCCIO), U1.24 (VCCIO), U1.26 (ACBUS2), U1.34 (~RESET), U1.38 (VCCCORE), U1.39 (VCCD), U1.40 (VREGIN), U2.5 (VOUT)
+5V: C13.1, C14.1, J1.1, U2.1 (VIN), U2.3 (INH)
/D+: J1.2, U1.7 (DP)
/D-: J1.3, U1.6 (DM)
/TCK: P1.1, U1.13 (ADBUS0)
/TDI: P1.9, U1.14 (ADBUS1)
/TDO: P1.3, U1.15 (ADBUS2)
/TMS: P1.5, U1.16 (ADBUS3)
GND: C1.1, C2.1, C3.1, C4.2, C5.1, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.5, P1.2, P1.10, R1.2, R2.2, U1.4 (AGND), U1.9 (AGND), U1.10 (GND), U1.11 (GND), U1.22 (GND), U1.23 (GND), U1.35 (GND), U1.36 (GND), U1.41 (AGND), U1.42 (TEST), U1.47 (GND), U1.48 (GND), U2.2 (GND)
unnamed: C1.2, C2.2, FB1.2, U1.8 (VPLL)
unnamed: C4.1, C6.1, FB2.2, U1.3 (VPHY)
unnamed: C10.1, U1.37 (VCCA)
unnamed: C11.1, U1.1 (XCSI), X1.2
unnamed: C12.1, U1.2 (XCS0), X1.1
unnamed: C15.1, U2.4 (BYP)
unnamed: D1.2 (K), R2.1
unnamed: D2.2 (K), P1.4
unnamed: R1.1, U1.5 (REF)

Notes on the sheet:
JTAG CONNECTOR
USB CONNECTOR + REGULATOR
Jorge Aparicio (C) 2012 Licensed under Creative Commons Attribution-ShareAlike 3.0 Unported (CC BY-SA 3.0)
USB TO JTAG

Board: 2 copper layers, 20.0 x 30.0 mm, 28 parts (18 on the bottom side), 18 nets.

## Commit log

2017-01-24 Forked the Repo, updated file types and relaid pcb.
2017-01-24 updated header to conform to the AVR JTAG style.
2017-01-24 added silk screen url and version.
